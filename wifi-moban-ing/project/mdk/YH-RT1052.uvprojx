# Keil uVision project YH-RT1052.uvprojx, settings and files
target itcm_txt_ram_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: YH-RT1052
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052CVL5B,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1 ,FSL_RTOS_FREE_RTOS,USE_RTOS=1,WICED_DISABLE_BOOTLOADER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\drivers;..\..\libraries\utilities;..\..\libraries\utilities\str;..\..\libraries\utilities\log;..\..\libraries\utilities\io;..\..\libraries\xip;..\..\user;..\..\user\bsp;..\..\..\WiFi_SDk\WICED\RTOS\FreeRTOS\ver9.0.0\Source\include;..\..\..\WiFi_SDk\WICED\RTOS\FreeRTOS\ver9.0.0\Source;..\..\..\WiFi_SDk\WICED\RTOS\FreeRTOS\ver9.0.0\Source\portable\RVDS\ARM_CM7\r0p1;..\..\..\WiFi_SDk\WICED\network\LwIP\ver2.0.3\port;..\..\..\WiFi_SDk\WICED\network\LwIP\ver2.0.3\src;..\..\..\WiFi_SDk\WICED\network\LwIP\ver2.0.3\src\include;..\..\lwip\contrib\apps;..\..\..\WiFi_SDk\include;..\..\..\WiFi_SDk\libraries\utilities\linked_list;..\..\..\WiFi_SDk\libraries\utilities\TLV;..\..\..\WiFi_SDk\resources\firmware\43362;..\..\..\WiFi_SDk\WICED\internal\unit;..\..\..\WiFi_SDk\WICED\internal;..\..\..\WiFi_SDk\WICED\network\LwIP\WWD;..\..\..\WiFi_SDk\WICED\network\LwIP\WWD\FreeRTOS;..\..\..\WiFi_SDk\WICED\network\LwIP\WWD\FreeRTOS\arch;..\..\..\WiFi_SDk\WICED\platform\MCU\iMXRT10xx;..\..\..\WiFi_SDk\WICED\platform\include;..\..\..\WiFi_SDk\WICED\platform\MCU\iMXRT10xx;..\..\..\WiFi_SDk\WICED\platform\MCU\iMXRT10xx\peripherals;..\..\..\WiFi_SDk\WICED\platform\MCU\iMXRT10xx\WWD;..\..\..\WiFi_SDk\WICED\WWD\include;..\..\..\WiFi_SDk\WICED\WWD\include\network;..\..\..\WiFi_SDk\WICED\WWD\include\platform;..\..\..\WiFi_SDk\WICED\WWD\include\RTOS;..\..\..\WiFi_SDk\WICED\WWD;..\..\..\WiFi_SDk\WICED\WWD\internal\bus_protocols;..\..\..\WiFi_SDk\WICED\WWD\internal\bus_protocols\SDIO;..\..\..\WiFi_SDk\WICED\WWD\internal\chips\43362;..\..\..\WiFi_SDk\WICED\RTOS\FreeRTOS\WWD;..\..\..\WiFi_SDk\WICED\WWD\internal;..\..\..\WiFi_SDk\WICED\platform\GCC;..\..\..\WiFi_SDk\WICED\security\BESL\crypto_internal;..\..\..\WiFi_SDk\WICED\security\BESL\mbedtls_open\include;..\..\..\WiFi_SDk\WICED\security\BESL\include;..\..\..\WiFi_SDk\WICED\RTOS\FreeRTOS\WICED;..\..\..\WiFi_SDk\WICED\platform\MCU;..\..\..\WiFi_SDk\libraries\utilities\ring_buffer;..\..\..\WiFi_SDk\WICED\RTOS\FreeRTOS\WWD\ARM_CM7;..\..\user\bsp\sdio\inc;..\..\user\bsp\sdio\port;..\..\..\WiFi_SDk\WICED\network\LwIP\WICED;..\..\..\WiFi_SDk\WICED\security\BESL\host\WICED;..\..\..\WiFi_SDk\WICED\network\LwIP\WWD\FreeRTOS\arch;..\..\..\WiFi_SDk\WICED\security\PostgreSQL\include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_itcm_txt_ram.scf
  group CMSIS
    ../../libraries/: system_MIMXRT1052.c system_MIMXRT1052.h
  group startup
    ./: startup_MIMXRT1052.s
  group drivers
    ../../libraries/drivers/: fsl_clock.c fsl_gpio.c fsl_lpuart.c fsl_common.c fsl_iomuxc.h fsl_enet.c fsl_usdhc.c
  group utilities
    ../../libraries/utilities/: fsl_assert.c fsl_notifier.c fsl_shell.c fsl_sbrk.c fsl_debug_console.c
    ../../libraries/utilities/str/: fsl_str.c
    ../../libraries/utilities/log/: fsl_log.c
    ../../libraries/utilities/io/: fsl_io.c
  group board
    ../../user/: board.c clock_config.c pin_mux.c fsl_phy.c
    ../../user/speedtest/: lwiperf.c netio.c
    ../../user/bsp/led/: bsp_led.c
  group user
    ../../user/: main.c client.c wifi_base_config.c
    ../../../WiFi_SDk/WICED/RTOS/FreeRTOS/WWD/ARM_CM7/: FreeRTOSConfig.h
    ../../../WiFi_SDk/WICED/network/LwIP/WWD/FreeRTOS/: lwipopts.h
  group xip
    ../../user/xip/: fire_imxrt1052_sdram_ini_dcd.c fire_imxrt1052_spiflash_config.c fsl_flexspi_nor_boot.c
  group doc
    ../../doc/: 必读说明.txt
  group FreeRTOS-Source-include
    ../../../WiFi_SDk/WICED/RTOS/FreeRTOS/ver9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS-Source
    ../../../WiFi_SDk/WICED/RTOS/FreeRTOS/ver9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS-Source-portable
    ../../../WiFi_SDk/WICED/RTOS/FreeRTOS/ver9.0.0/Source/portable/MemMang/: heap_3.c
    ../../../WiFi_SDk/WICED/RTOS/FreeRTOS/ver9.0.0/Source/portable/RVDS/ARM_CM7/r0p1/: port.c fsl_tickless_systick.c
  group lwip-port
    ../../../WiFi_SDk/WICED/network/LwIP/WWD/FreeRTOS/: sys_arch.c
  group lwip-src-api
    ../../../WiFi_SDk/WICED/network/LwIP/ver2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../../WiFi_SDk/WICED/network/LwIP/ver2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-ipv4
    ../../../WiFi_SDk/WICED/network/LwIP/ver2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-ipv6
    ../../../WiFi_SDk/WICED/network/LwIP/ver2.0.3/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-lwip
    ../../../WiFi_SDk/WICED/network/LwIP/ver2.0.3/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip_addr.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
  group lwip-src-include-priv
    ../../../WiFi_SDk/WICED/network/LwIP/ver2.0.3/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-lwip-prot
    ../../../WiFi_SDk/WICED/network/LwIP/ver2.0.3/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip-src-include-netif
    ../../../WiFi_SDk/WICED/network/LwIP/ver2.0.3/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
  group lwip-src-include-netif-ppp
    ../../../WiFi_SDk/WICED/network/LwIP/ver2.0.3/src/include/netif/ppp/: ccp.h chap_ms.h chap-md5.h chap-new.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ../../../WiFi_SDk/WICED/network/LwIP/ver2.0.3/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip-src-include-posix
    ../../../WiFi_SDk/WICED/network/LwIP/ver2.0.3/src/include/posix/: errno.h netdb.h
  group lwip-src-include-posix-sys
    ../../../WiFi_SDk/WICED/network/LwIP/ver2.0.3/src/include/posix/sys/: socket.h
  group lwip-src-netif
    ../../../WiFi_SDk/WICED/network/LwIP/ver2.0.3/src/netif/: ethernet.c ethernetif.c lowpan6.c
  group WiFi
    ../../../WiFi_SDk/WICED/WWD/internal/bus_protocols/SDIO/: wwd_bus_protocol.c
    ../../../WiFi_SDk/WICED/WWD/internal/bus_protocols/: wwd_bus_common.c
    ../../../WiFi_SDk/WICED/WWD/internal/chips/43362/: wwd_ap.c wwd_chip_specific_functions.c
    ../../../WiFi_SDk/WICED/WWD/internal/: wwd_ap_common.c wwd_debug.c wwd_eapol.c wwd_internal.c wwd_logging.c wwd_management.c wwd_rtos_interface.c wwd_sdpcm.c wwd_thread.c wwd_thread_internal.c wwd_wifi.c wwd_wifi_chip_common.c wwd_wifi_sleep.c
    ../../../WiFi_SDk/WICED/RTOS/FreeRTOS/WWD/: wwd_rtos.c
    ../../../WiFi_SDk/WICED/platform/MCU/iMXRT10xx/WWD/: wlan_bus_sdio.c wwd_platform.c
    ../../../WiFi_SDk/WICED/platform/MCU/: platform_resource.c wwd_resources.c wwd_platform_separate_mcu.c
    ../../../WiFi_SDk/WICED/platform/ARM_CM7/: host_cm7.c
    ../../../WiFi_SDk/WICED/network/LwIP/WWD/: wwd_buffer.c wwd_network.c
    ../../../WiFi_SDk/resources/firmware/43362/: 43362A2_bin.c
    ../../../WiFi_SDk/libraries/utilities/TLV/: tlv.c
    ../../../WiFi_SDk/libraries/utilities/ring_buffer/: ring_buffer.c
    ../../../WiFi_SDk/WICED/internal/: wiced_lib.c wiced_crypto.c
  group WiFi-sdio
    ../../user/bsp/sdio/src/: fsl_sdio.c fsl_sdmmc_common.c
    ../../user/bsp/sdio/port/usdhc/freertos/: fsl_sdmmc_event.c fsl_sdmmc_host.c
target itcm_txt_sdram_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052CVL5B,SKIP_SYSCLK_INIT,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1 ,FSL_RTOS_FREE_RTOS,USE_RTOS=1,WICED_DISABLE_BOOTLOADER
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_itcm_txt_sdram.scf
target sdram_txt_ram_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: as above
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_sdram_txt_ram.scf
target nor_txt_ram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052CVL5B,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,FSL_RTOS_FREE_RTOS,USE_RTOS=1,WICED_DISABLE_BOOTLOADER
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_nor_txt_ram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
target nor_txt_sdram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052CVL5B,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1 ,FSL_RTOS_FREE_RTOS,USE_RTOS=1,WICED_DISABLE_BOOTLOADER
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_nor_txt_sdram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
target nor_itcm_txt_ram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052CVL5B,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,USE_RAM_VECTOR_TABLE ,FSL_RTOS_FREE_RTOS,USE_RTOS=1,WICED_DISABLE_BOOTLOADER
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_nor_itcm_txt_ram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
target nor_sdram_txt_sdram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_nor_sdram_txt_sdram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
