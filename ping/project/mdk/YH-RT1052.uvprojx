# Keil uVision project YH-RT1052.uvprojx, settings and files
target ram_debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: YH-RT1052
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052DVL6B,SKIP_SYSCLK_INIT,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,FSL_RTOS_FREE_RTOS,USE_RTOS=1,WICED_DISABLE_BOOTLOADER,WWD_BUS_SDIO_USE_WLAN_SDIO_PULLUPS,NO_WICED_API,DHCP_DEBUG
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\drivers;..\..\libraries\utilities;..\..\libraries\utilities\str;..\..\libraries\utilities\log;..\..\libraries\utilities\io;..\..\libraries\xip;..\..\user;..\..\user\bsp;..\..\WiFi\WICED\RTOS\FreeRTOS\ver9.0.0\Source\include;..\..\WiFi\WICED\RTOS\FreeRTOS\ver9.0.0\Source;..\..\WiFi\WICED\RTOS\FreeRTOS\ver9.0.0\Source\portable\RVDS\ARM_CM7\r0p1;..\..\WiFi\WICED\network\LwIP\ver2.0.3\port;..\..\WiFi\WICED\network\LwIP\ver2.0.3\src;..\..\WiFi\WICED\network\LwIP\ver2.0.3\src\include;..\..\lwip\contrib\apps;..\..\WiFi\include;..\..\WiFi\libraries\utilities\linked_list;..\..\WiFi\libraries\utilities\TLV;..\..\WiFi\resources\firmware\43362;..\..\WiFi\WICED\internal\unit;..\..\WiFi\WICED\internal;..\..\WiFi\WICED\network\LwIP\WWD;..\..\WiFi\WICED\network\LwIP\WWD\FreeRTOS;..\..\WiFi\WICED\network\LwIP\WWD\FreeRTOS\arch;..\..\WiFi\WICED\platform\MCU\iMXRT10xx;..\..\WiFi\WICED\platform\include;..\..\WiFi\WICED\platform\MCU\iMXRT10xx;..\..\WiFi\WICED\platform\MCU\iMXRT10xx\peripherals;..\..\WiFi\WICED\platform\MCU\iMXRT10xx\WWD;..\..\WiFi\WICED\WWD\include;..\..\WiFi\WICED\WWD\include\network;..\..\WiFi\WICED\WWD\include\platform;..\..\WiFi\WICED\WWD\include\RTOS;..\..\WiFi\WICED\WWD;..\..\WiFi\WICED\WWD\internal\bus_protocols;..\..\WiFi\WICED\WWD\internal\bus_protocols\SDIO;..\..\WiFi\WICED\WWD\internal\chips\43362;..\..\WiFi\WICED\RTOS\FreeRTOS\WWD;..\..\WiFi\WICED\WWD\internal;..\..\WiFi\WICED\platform\GCC;..\..\WiFi\WICED\security\BESL\crypto_internal;..\..\WiFi\WICED\security\BESL\mbedtls_open\include;..\..\WiFi\WICED\security\BESL\include;..\..\WiFi\WICED\RTOS\FreeRTOS\WICED;..\..\WiFi\WICED\platform\MCU;..\..\WiFi\libraries\utilities\ring_buffer;..\..\WiFi\WICED\RTOS\FreeRTOS\WWD\ARM_CM7;..\..\user\bsp\sdio\inc;..\..\user\bsp\sdio\port;..\..\WiFi\WICED\network\LwIP\WICED;..\..\WiFi\WICED\security\BESL\host\WICED;..\..\WiFi\WICED\network\LwIP\WWD\FreeRTOS\arch;..\..\WiFi\WICED\security\PostgreSQL\include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_sdram_txt_ram.scf
  group CMSIS
    ../../libraries/: system_MIMXRT1052.c system_MIMXRT1052.h
  group startup
    ./: startup_MIMXRT1052.s
  group drivers
    ../../libraries/drivers/: fsl_clock.c fsl_gpio.c fsl_lpuart.c fsl_common.c fsl_iomuxc.h fsl_enet.c fsl_usdhc.c
  group utilities
    ../../libraries/utilities/: fsl_assert.c fsl_notifier.c fsl_shell.c fsl_sbrk.c fsl_debug_console.c
    ../../libraries/utilities/str/: fsl_str.c
    ../../libraries/utilities/log/: fsl_log.c
    ../../libraries/utilities/io/: fsl_io.c
  group board
    ../../user/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h fsl_phy.c
    ../../user/bsp/led/: bsp_led.c
    ../../user/speedtest/: netio.c lwiperf.c
  group user
    ../../user/: main.c ping.c client.c
    ../../WiFi/WICED/RTOS/FreeRTOS/WWD/ARM_CM7/: FreeRTOSConfig.h
    ../../WiFi/WICED/network/LwIP/WWD/FreeRTOS/: lwipopts.h
  group xip
    ../../user/xip/: fire_imxrt1052_sdram_ini_dcd.c fire_imxrt1052_spiflash_config.c fsl_flexspi_nor_boot.c
  group doc
    ../../doc/: 必读说明.txt
  group FreeRTOS-Source-include
    ../../WiFi/WICED/RTOS/FreeRTOS/ver9.0.0/Source/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS-Source
    ../../WiFi/WICED/RTOS/FreeRTOS/ver9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS-Source-portable
    ../../WiFi/WICED/RTOS/FreeRTOS/ver9.0.0/Source/portable/MemMang/: heap_3.c
    ../../WiFi/WICED/RTOS/FreeRTOS/ver9.0.0/Source/portable/RVDS/ARM_CM7/r0p1/: port.c fsl_tickless_systick.c
  group lwip-port
    ../../WiFi/WICED/network/LwIP/WWD/FreeRTOS/: sys_arch.c
  group lwip-src-api
    ../../WiFi/WICED/network/LwIP/ver2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-src-core
    ../../WiFi/WICED/network/LwIP/ver2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-src-ipv4
    ../../WiFi/WICED/network/LwIP/ver2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip-src-ipv6
    ../../WiFi/WICED/network/LwIP/ver2.0.3/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip-src-include-lwip
    ../../WiFi/WICED/network/LwIP/ver2.0.3/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip_addr.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
  group lwip-src-include-priv
    ../../WiFi/WICED/network/LwIP/ver2.0.3/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
  group lwip-src-include-lwip-prot
    ../../WiFi/WICED/network/LwIP/ver2.0.3/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h ethernet.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip-src-include-netif
    ../../WiFi/WICED/network/LwIP/ver2.0.3/src/include/netif/: etharp.h ethernet.h lowpan6.h lowpan6_opts.h slipif.h
  group lwip-src-include-netif-ppp
    ../../WiFi/WICED/network/LwIP/ver2.0.3/src/include/netif/ppp/: ccp.h chap_ms.h chap-md5.h chap-new.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip-src-include-netif-ppp-polarssl
    ../../WiFi/WICED/network/LwIP/ver2.0.3/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip-src-include-posix
    ../../WiFi/WICED/network/LwIP/ver2.0.3/src/include/posix/: errno.h netdb.h
  group lwip-src-include-posix-sys
    ../../WiFi/WICED/network/LwIP/ver2.0.3/src/include/posix/sys/: socket.h
  group lwip-src-netif
    ../../WiFi/WICED/network/LwIP/ver2.0.3/src/netif/: ethernet.c ethernetif.c lowpan6.c
  group WiFi
    ../../WiFi/WICED/WWD/internal/bus_protocols/SDIO/: wwd_bus_protocol.c
    ../../WiFi/WICED/WWD/internal/bus_protocols/: wwd_bus_common.c
    ../../WiFi/WICED/WWD/internal/chips/43362/: wwd_ap.c wwd_chip_specific_functions.c
    ../../WiFi/WICED/WWD/internal/: wwd_ap_common.c wwd_debug.c wwd_eapol.c wwd_internal.c wwd_logging.c wwd_management.c wwd_rtos_interface.c wwd_sdpcm.c wwd_thread.c wwd_thread_internal.c wwd_wifi.c wwd_wifi_chip_common.c wwd_wifi_sleep.c
    ../../WiFi/WICED/RTOS/FreeRTOS/WWD/: wwd_rtos.c
    ../../WiFi/WICED/platform/MCU/iMXRT10xx/WWD/: wlan_bus_sdio.c wwd_platform.c
    ../../WiFi/WICED/platform/MCU/: platform_resource.c wwd_resources.c wwd_platform_separate_mcu.c
    ../../WiFi/WICED/platform/ARM_CM7/: host_cm7.c
    ../../WiFi/WICED/network/LwIP/WWD/: wwd_buffer.c wwd_network.c
    ../../WiFi/resources/firmware/43362/: 43362A2_bin.c
    ../../WiFi/libraries/utilities/TLV/: tlv.c
    ../../WiFi/libraries/utilities/ring_buffer/: ring_buffer.c
    ../../WiFi/WICED/internal/: wiced_lib.c wiced_crypto.c
  group WiFi-sdio
    ../../user/bsp/sdio/src/: fsl_sdio.c fsl_sdmmc_common.c
    ../../user/bsp/sdio/port/usdhc/freertos/: fsl_sdmmc_event.c fsl_sdmmc_host.c
target nor_txt_ram (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: YH-RT1052 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052DVL6B,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1,FSL_RTOS_FREE_RTOS,USE_RTOS=1,WICED_DISABLE_BOOTLOADER
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186,111
  c include: as above
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_nor_txt_ram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
